Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2023-06-21T17:28:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 17:28:43 2023 * Host: LIS-C-00085 * Database: C:\Users\MOA2OVR\AppData\Local\Temp\{9E972DE2-0F32-48DE-B18C-F14BD984FC0A}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 17:28:42 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 17:28:43 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 17:28:43 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: Motion_Detector_360°_Ceiling_Mount, Intrusion-Products_Bosch_Motion_detector_360º_ceiling_mount:Motion_Detector_360°_Ceiling_Mount:234018
In: Level 1
Type - PredefinedType: MOVEMENTSENSOR; Classification: Pr_75_80_42_16 Combined passive infrared and microwave movement detectors (Uniclass 2015); Material: Xtech_Bosch_ABS_White, GLASS 001
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - 2DSymbolOffset: 5 mm; Dimension height (cm): 8.9; Dimension horizontal diameter (cm): 17.8
Type - General - Detector type: Panoramic Detectors; Environmental class: II; Operating temperature (°C) (maximum): 49; Operating temperature (°C) (minimum): -40; Operating voltage (VDC) (maximum): 15; Operating voltage (VDC) (minimum): 9
Type - Identity Data - CTN: DS939; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; Family Version: 0; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS939_Installation_Manual_enUS_2632417931.pdf; Material number: 4.998.800.703; OmniClass Number: 23.85.30.14.31; OmniClass Title: Infra-Red Radiation Detectors; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS939_Installation_Manual_enUS_2632417931.pdf; Product Description: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS939_Data_sheet_enUS_2632399371.pdf; Product Information: Motion_Detector_360°_Ceiling_Mount; Product Website: https://commerce.boschsecurity.com/nordics/en/DS939-Series-Panoramic-Detectors/p/4.998.800.703/; Type Name: Motion_Detector_360°_Ceiling_Mount
Type - Materials and Finishes - Color: White
Type - Other - Category: Security Devices; 2D_Flipped Position: yes; Family Name: Intrusion-Products_Bosch_Motion_detector_360º_ceiling_mount
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Volume: 0.000670987 m3
Electrical - Circuiting - Electrical Data: 0 V/1-0 VA
Identity Data - Mark: 24
Other - 2D_Original Position: no; Family: Intrusion-Products_Bosch_Motion_detector_360º_ceiling_mount: Motion_Detector_360°_Ceiling_Mount; Family and Type: Intrusion-Products_Bosch_Motion_detector_360º_ceiling_mount: Motion_Detector_360°_Ceiling_Mount; Schedule Level: Level: Level 1; Type: Intrusion-Products_Bosch_Motion_detector_360º_ceiling_mount: Motion_Detector_360°_Ceiling_Mount; Type Id: Intrusion-Products_Bosch_Motion_detector_360º_ceiling_mount: Motion_Detector_360°_Ceiling_Mount
Phasing - Phase Created: New Construction
